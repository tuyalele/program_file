# Keil uVision project 温度湿度检测.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15W4K32S4 STC
  cpu: IRAM(0-0xFF) XRAM(0-0xEFF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: 温度湿度检测 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\H;.\mcu_sdk;.\UART;.\0.96OLED;.\SHT30
  group Source Group 1
    ./: main.c
  group UART
    ./UART/: UART interrupt.c UART.c
  group H
    ./H/: delay.c TIME interrupt.c timer.c reda_data.c key.c
  group mcu_sdk
    ./mcu_sdk/: mcu_api.c protocol.c system.c
  group 0.96OLED
    ./0.96OLED/: oled.c
  group SHT30
    ./SHT30/: SHT3X.C
